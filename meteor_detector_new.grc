<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>meteor_detector</value></param>
<param><key>author</key><value>Marcus Leech</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Meteor detection using broadcast VHF</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>VHF Meteor Detection Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>F1</value></param>
<param><key>value</key><value>freq1-Fc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>F2</value></param>
<param><key>value</key><value>freq2-Fc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>F3</value></param>
<param><key>value</key><value>freq3-Fc</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>Fc</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>cfreq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,7,1,1</value></param>
<param><key>label</key><value>Fc</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>bandwidth_1</value></param>
<param><key>choices</key><value>[500, 1000, 2000, 3000]</value></param>
<param><key>value</key><value>bw1</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Detector Bandwidth (Hz)</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>bandwidth_2</value></param>
<param><key>choices</key><value>[500, 1000, 2000, 3000]</value></param>
<param><key>value</key><value>bw2</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Detector Bandwidth (Hz)</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,3</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>bandwidth_3</value></param>
<param><key>choices</key><value>[500, 1000, 2000, 3000]</value></param>
<param><key>value</key><value>bw3</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Detector Bandwidth (Hz)</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,4</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_files</value></param>
<param><key>value</key><value>["met-bb-fifo0", "met-bb-fifo1", "met-bb-fifo2"]</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>chan1_value</value></param>
<param><key>block_id</key><value>chan1_pwr</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>meteor_helper.getHz()</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>chan2_value</value></param>
<param><key>block_id</key><value>chan2_pwr</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>meteor_helper.getHz()</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>chan3_value</value></param>
<param><key>block_id</key><value>chan3_pwr</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>meteor_helper.getHz()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_filter</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,int(samp_rate),(chan_width/2.2),(chan_width/3),firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>chan_trigger_poll</value></param>
<param><key>block_id</key><value>chan1_pwr</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_width</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_write_1</value></param>
<param><key>value</key><value>meteor_helper.write_chan(1,chan1_value,freq1,thresh,record_1,dc_gain_1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_write_2</value></param>
<param><key>value</key><value>meteor_helper.write_chan(2,chan2_value,freq2,thresh,record_2,dc_gain_2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_write_3</value></param>
<param><key>value</key><value>meteor_helper.write_chan(3,chan3_value,freq3,thresh,record_3,dc_gain_3)</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>cur_time</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>meteor_helper.current_time(chan_trigger_poll)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Current Time</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dc_gain_1</value></param>
<param><key>choices</key><value>[1,5,10,20,50]</value></param>
<param><key>value</key><value>dgain1</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Detector Gain</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dc_gain_2</value></param>
<param><key>choices</key><value>[1,5,10,20,50]</value></param>
<param><key>value</key><value>dgain2</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Detector Gain</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,3</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dc_gain_3</value></param>
<param><key>choices</key><value>[1,5,10,20,50]</value></param>
<param><key>value</key><value>dgain3</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Detector Gain</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,4</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>detector_rate</value></param>
<param><key>value</key><value>5.0e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_len</value></param>
<param><key>value</key><value>len(chan_filter)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>ftune</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Fine Tuning</value></param>
<param><key>max</key><value>15e3</value></param>
<param><key>min</key><value>-15e3</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>f1</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ch 1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>f2</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Ch 2</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq3</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>f3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Ch 3</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>iagc</value></param>
<param><key>value</key><value>xx</value></param>
<param><key>false</key><value>0</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>AGC</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>true</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_filter</value></param>
<param><key>value</key><value>gr.firdes_low_pass(1.0,samp_rate,samp_rate/2.2,samp_rate/3.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_len</value></param>
<param><key>value</key><value>len(input_filter)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>offs</value></param>
<param><key>grid_pos</key><value>0,8,1,1</value></param>
<param><key>label</key><value>LO Offset</value></param>
<param><key>max</key><value>250e3</value></param>
<param><key>min</key><value>25e3</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>post_det_rate</value></param>
<param><key>value</key><value>meteor_helper.getHz()/2</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>record_1</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Record Baseband</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>record_2</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Record Baseband</value></param>
<param><key>notebook</key><value>Main,3</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>record_3</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Record Baseband</value></param>
<param><key>notebook</key><value>Main,4</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rfg</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>rfgain</value></param>
<param><key>grid_pos</key><value>1,1,1,2</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>thread_start_stats</value></param>
<param><key>value</key><value>meteor_helper.start_threads(bb_files)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>thresh</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>trig</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Trigger Threshold</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>2</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_1</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs1[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Trig state</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_1_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs1[1]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_1_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs1[2]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Count</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_1_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs1[3]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_2</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs2[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Trig state</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_2_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs2[1]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_2_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs2[2]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Count</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_2_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs2[3]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_3</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs3[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Trig state</value></param>
<param><key>notebook</key><value>Main,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_3_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs3[1]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>notebook</key><value>Main,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_3_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs3[2]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Count</value></param>
<param><key>notebook</key><value>Main,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>trig_state_3_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>trigs3[3]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Rate</value></param>
<param><key>notebook</key><value>Main,4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trigs1</value></param>
<param><key>value</key><value>meteor_helper.trig_state(1,chan_trigger_poll)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trigs2</value></param>
<param><key>value</key><value>meteor_helper.trig_state(2,chan_trigger_poll)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>trigs3</value></param>
<param><key>value</key><value>meteor_helper.trig_state(3,chan_trigger_poll)</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq1</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ch 1 Freq</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq2</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ch 2 Freq</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq3</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ch 3 Freq</value></param>
<param><key>notebook</key><value>Main,4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xx</value></param>
<param><key>value</key><value>False if agc == 0 else True</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>labels</key><value>['Main Spectral','Detectors','Ch1 Detail', 'Ch 2 Detail', 'Ch 3 Detail']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>agc</value></param>
<param><key>label</key><value>AGC Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>comment</key><value>?Append file?</value></param>
<param><key>file</key><value>bb_files[0]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>comment</key><value>?Append file?</value></param>
<param><key>file</key><value>bb_files[1 ]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>comment</key><value>?Append file?</value></param>
<param><key>file</key><value>bb_files[2]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0</value></param>
<param><key>n</key><value>int(detector_rate/post_det_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0_0_1</value></param>
<param><key>n</key><value>int(detector_rate/post_det_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.285</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>dc_gain_1*5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>dc_gain_2*5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>dc_gain_3*5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw1</value></param>
<param><key>label</key><value>Detector Bandwidth Ch1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw2</value></param>
<param><key>label</key><value>Detector Bandwidth Ch2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw3</value></param>
<param><key>label</key><value>Detector Bandwidth Ch3</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfreq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>216.980e6</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>chan1_pwr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>chan2_pwr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>chan3_pwr_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dgain1</value></param>
<param><key>label</key><value>DC Gain Chan 1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dgain2</value></param>
<param><key>label</key><value>DC Gain Chan 2</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dgain3</value></param>
<param><key>label</key><value>DC Gain Chan 3</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f1</value></param>
<param><key>label</key><value>F1 Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>216.970e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f2</value></param>
<param><key>label</key><value>F2 Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>216.980e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f3</value></param>
<param><key>label</key><value>F3 Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>216.990e6</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>(-F1)</value></param>
<param><key>decim</key><value>int(samp_rate/chan_width)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>chan_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>(-F2)</value></param>
<param><key>decim</key><value>int(samp_rate/chan_width)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>chan_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0</value></param>
<param><key>center_freq</key><value>(-F3)</value></param>
<param><key>decim</key><value>int(samp_rate/chan_width)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>chan_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>center_freq</key><value>(offset)+((Fc/1.0e6 * ppm))+fine</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>input_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ftune</value></param>
<param><key>label</key><value>Fine Tuning</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import  meteor_helper</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>alias</key><value>dffgfdgs</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>keep_one_in_n_0_0_0_0</value></param>
<param><key>n</key><value>int(detector_rate/post_det_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth_1/2</value></param>
<param><key>decim</key><value>int(chan_width/detector_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>(bandwidth_1/2)/3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth_2/2</value></param>
<param><key>decim</key><value>int(chan_width/detector_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>(bandwidth_2/2)/3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth_3/2</value></param>
<param><key>decim</key><value>int(chan_width/detector_rate)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>(bandwidth_3/2)/3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate/2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate/2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0_0</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate/2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0_0_0</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate*2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0_1</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate*2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_1</value></param>
<param><key>cutoff_freq</key><value>1200</value></param>
<param><key>decim</key><value>int(chan_width/(detector_rate*2))</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>5</value></param>
<param><key>samp_rate</key><value>chan_width</value></param>
<param><key>width</key><value>600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offs</value></param>
<param><key>label</key><value>LO Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>25.0e3</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>Fc+(offset)</value></param>
<param><key>gain_mode0</key><value>iagc</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>25 if iagc else rfg</value></param>
<param><key>args</key><value>devid</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>PPM LO Accuracy</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(detector_rate/10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>1.0/(detector_rate/10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>alpha</key><value>1.0/(detector_rate/10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>trig</value></param>
<param><key>label</key><value>Trigger Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.5</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>Fc</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>8</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Instantaneous Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>700,150</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>samp_rate</key><value>post_det_rate</value></param>
<param><key>t_scale</key><value>450</value></param>
<param><key>title</key><value>Detected Power</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>10e-6</value></param>
<param><key>v_scale</key><value>5e-6</value></param>
<param><key>win_size</key><value>700,300</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Relative Power</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>Fc</value></param>
<param><key>dynamic_range</key><value>10</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-40</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Spectrogram</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>700,425</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>10</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-53</value></param>
<param><key>samp_rate</key><value>detector_rate/2</value></param>
<param><key>title</key><value>Ch 1 Spectrum Detail</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>700,525</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>10</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,3</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-53</value></param>
<param><key>samp_rate</key><value>detector_rate/2</value></param>
<param><key>title</key><value>Ch 2 Spectrum Detail</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>700,525</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>10</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>Main,4</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-53</value></param>
<param><key>samp_rate</key><value>detector_rate/2</value></param>
<param><key>title</key><value>Ch 3 Spectrum Detail</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>700,525</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>chan1_pwr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>chan2_pwr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>chan3_pwr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>complex_to_mag_squared_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>low_pass_filter_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>low_pass_filter_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>low_pass_filter_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>keep_one_in_n_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>keep_one_in_n_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
